# Keil uVision project ADCBurst.uvproj, settings and files
target ReleaseInFlash (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: ADCBurst
  AfterMake: fromelf.exe --bin -o .\ReleaseInFlash\ADCBurst.bin .\ReleaseInFlash\ADCBurst.axf
  c flags: Optim=1
  c include: .\CM0;.\LPC11xx;.\LPC11xx\startup;.\USER_CODE
  asm define: EN_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group CMSIS FILES
    ./CM0/: core_cm0.c
    ./LPC11xx/: system_LPC11xx.c
    ./LPC11xx/startup/: startup_LPC11xx.s
  group User Code
    ./USER_CODE/: main.c
target DebugInFlash (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: ADCBurst
  AfterMake: fromelf.exe --bin -o .\DebugInFlash\ADCBurst.bin .\DebugInFlash\ADCBurst.axf
  c flags: Optim=1
  c include: .\CM0;.\LPC11xx;.\LPC11xx\startup;.\USER_CODE
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
